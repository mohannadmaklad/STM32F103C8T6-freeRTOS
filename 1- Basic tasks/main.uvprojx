# Keil uVision project main.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: E:\RTOS\My\1\Source\include;.\Source\ARM_CM3;.\Source\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c lcd.c ds.c
    ./Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./Source/MemMang/: heap_2.c
    ./Source/ARM_CM3/: port.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
